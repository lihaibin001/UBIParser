# IAR project DR002_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105VB ST STM32F105VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3
  ICCARM.CCIncludePath2: .; ..\bootloader_src; ..\bootloader_src\library; ..\bootloader_src\library\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DR002_bootloader.hex
  ILINK.IlinkOutputFile: DR002_bootloader.out
  ILINK.IlinkIcfFile: ..\bootloader_src\Linkfile\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group boot_app
    ../bootloader_src/: common.c main.c spi_flash.c stm32f10x_it.c
  group drivers
    ../bootloader_src/library/: cortexm3_macro.s stm32f10x_vector.c
    ../bootloader_src/library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c
  group linkfile
    ../bootloader_src/Linkfile/: STM32F10x_FLASH.icf
