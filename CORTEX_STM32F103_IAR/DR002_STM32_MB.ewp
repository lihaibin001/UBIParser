# IAR project DR002_STM32_MB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105RC ST STM32F105RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\main_app\Diag_Factory; ..\main_app\common; ..\main_app\power; ..\main_app\SysMan; ..\main_app\Protocol; ..\main_app\include; ..\main_app\FreeRTOS\include; ..\main_app\FreeRTOS\portable\IAR\ARM_CM3; ..\main_app\Arch\stm32f1\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\main_app\drivers; ..\main_app\Arch\stm32f1\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\main_app\Arch\stm32f1\Libraries\CMSIS\CM3\CoreSupport; ..\main_app\GPS; ..\main_app\GPRS; ..\main_app\Sensors
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; ..\main_app\FreeRTOS\include
  OBJCOPY.OOCOutputFile: DR002_STM32_MB.hex
  ILINK.IlinkOutputFile: DR002_STM32_MB.out
  ILINK.IlinkIcfFile: ..\main_app\Linkfile\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common
    ../main_app/common/: crc_ccitt.c delay.c diag_task.c gensubs.c main.c param.c periodic.c record_task.c ring_buf.c rtos.c str_lib.c
  group drivers
    ../main_app/drivers/: cortexm3_macro.s spi_flash.c stm32f10x_it.c uart.c
    ../main_app/Arch/stm32f1/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ../main_app/Arch/stm32f1/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group FreeRTOS
    ../main_app/FreeRTOS/portable/MemMang/: heap_2.c
    ../main_app/FreeRTOS/: list.c queue.c tasks.c timer.c
    ../main_app/FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s
  group GPRS
    ../main_app/GPRS/: ATApp.c ATProtocol.c GPRS.c TelmApp.c TelmProtocol.c
  group GPS
    ../main_app/GPS/: gps.c
  group MFG
    ../main_app/Diag_Factory/: Diag_man.c
  group power
    ../main_app/Power/: ACC_Detect.c fsm.c int2evt.c lowpower.c powerfail.c Psync.c regulator.c relays.c
  group Sensors
    ../main_app/Sensors/: bma2x2.c bma2x2_app.c bmi160.c bmi160_app.c Sensors.c
  group system files
    ../main_app/SysMan/: system.c
    ../main_app/Arch/stm32f1/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
